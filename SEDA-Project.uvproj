# Keil uVision project SEDA-Project.uvproj, settings and files
target LPC1768 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: SEDA-Project
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group system
    ./src/TCP-IP/lib/: Net_Config.c Net_Debug.c Net_Config.h RTL.h Net_lib.c EMAC_LPC17xx_LAN8720.h EMAC_LPC17xx_LAN8720.c TCP_CM3.lib TCPD_CM3.lib
    ./system/: system_LPC17xx.c startup_LPC17xx.s
    ./src/LCD/: AsciiLib.c font.c GLCD.c lpc17xx_clkpwr.c lpc17xx_gpio.c lpc17xx_libcfg_default.c
  group src
    ./src/TCP-IP/: HTTP_CGI.c tcp.c
    ./src/: main.c
    ./src/PWM/: pwm.c
    ./src/UART/: uart.c uart0.c uart2.c uart3.c
    ./src/ANEMOMETRO/: anemometro.c
    ./src/AUDIO/: audio.c
    ./src/LCD/: lcddriver.c visualizacion.c
    ./src/SENSORES/: temp-humedad.c
  group headers
    ./src/: headers.h
    ./src/PWM/: pwm.h
    ./src/UART/: uart.h
    ./src/TCP-IP/: tcp.h
    ./src/ANEMOMETRO/: anemometro.h
    ./src/AUDIO/: audio.h audio_muestras.h
    ./src/LCD/: lcd.h lcddriver.h
    ./src/SENSORES/: sensores.h
  group HTTP
    ./src/TCP-IP/web/: index.cgi web.c Web.inp
